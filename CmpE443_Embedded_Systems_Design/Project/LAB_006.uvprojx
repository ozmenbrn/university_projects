# Keil uVision project LAB_006.uvprojx, settings and files
target NXP_LPC4088 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LAB_006
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ./: main.c
  group Library
    ./Library/: Timer.c GPIO.c LED.c Joystick.c Joystick.h
    ./: Wait.c Wait.h PWM.c PWM.h Parameters.h Parameters.c Ultrasonic.c ADC.c ADC.h ESP8266.h ESP8266.c Serial.c Serial.h External.c External.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
